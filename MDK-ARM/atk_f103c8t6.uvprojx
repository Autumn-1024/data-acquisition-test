# Keil uVision project atk_f103c8t6.uvprojx, settings and files
target atk_f103c8t6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103c8t6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE,USE_HAL_DRIVER
  c include: ..\Core\Inc;..\BSP\Inc;..\App\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/Startup/: startup_stm32f103xe.s
    ../Core/Src/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group BSP
    ../BSP/Src/: bsp_led.c bsp_key.c bsp_uart.c bsp_oled.c bsp_sensor_ultrasonic.c bsp_sensor_resistive.c bsp_sensor_hall.c bsp_sensor_capacitive.c bsp_sensor_inductive.c bsp_sensor_photoelec.c
  group App
    ../App/Src/: app_task.c app_menu.c
  group Drivers
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Docs
    ../: README.md
